Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-11-07T15:58:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 07 15:58:57 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\3e4fa020-c178-41bf-bba9-c2bca2ec3991\9b68dd10-badf-4350-9d90-315e522cc18a\ifc * Database version: 5507 * Database creation date: Fri Nov 07 15:58:56 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Nov 07 15:58:56 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 07 15:58:56 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcDistributionPort, Port_328230
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: 2840 - Preto, Mini_Balizador_Romi_2839_2840_Nordecor_IFC:2840 - Preto:328230
In: Nível 1
Type - Classification: D5020200 Lighting Equipment (Uniformat); Material: Metal - Alumínio - Preto, Plástico - Acrílico - Transparente
Type - Cotas - Altura: 36 mm; Diâmetro: 26 mm
Type - Dados - Data da atualização: 07/11/2024; Versão: 1
Type - Dados de identidade - Código de montagem: D5020200; Código Uniformat: D5020.20; Comentários de tipos: mini balizador de embutir, acabamento branco ou preto, LED 1W, 3000K, fluxo 25lm, luz decorativa de orientação, uso interno ou externo protegido; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Mini balizador de embutir redondo, acabamento branco, LED 1W, 3000K 25lm; Descrição de montagem: Lighting Equipment; Descrição UniFormat: Luminárias e acessórios; Desenvolvedor: Chek BIM; Fabricante: Nordecor; Fixação: Molas; Garantia: 2 anos; Grau de proteção: IP20; Localização: Camboriú/SC - Brasil; Modelo: 2840; Nome do tipo: 2840 - Preto; Nota-chave: 26 51 19; Número MasterFormat: 26 51 19; Número OmniClass: 23.80.70.11.14; Observação: Drive integrado; Tipo de imagem: Imagem raster: 2840.png; Tipo de luminária: Distribuição Assimétrica / Luz de balizamento; Título MasterFormat: Luminárias de Parede; Título OmniClass: General Luminaries, Directional; URL: https://nordecor.com.br; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/mini-balizador-led-embutir-quad-romi-1w-3-000k/
Type - Elétrico - Comentários de voltagem: 100-240V; Fator de potência - Luminária: 0.5; Lâmpada: LED
Type - Elétrico - Cargas - Carga aparente - Luminária: 0 W
Type - Engenharia elétrica - Voltagem - Luminária: 0 V
Type - Estrutural - Peso da luminária: 0
Type - Fotométricos - Fluxo luminoso: 25 lm; IRC: 90; Potência: 1 W; Temperatura da cor: 3000 K
Type - Materiais e acabamentos - Difusor: Plástico - Acrílico - Transparente; Dissipador: Metal - Alumínio - Preto; Luminária: Metal - Alumínio - Preto
Type - Outros - Categoria: Luminárias; Branco: no; Nome da família: Mini_Balizador_Romi_2839_2840_Nordecor_IFC; Preto: yes
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 2840 - Preto; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.00243788 m2; Volume: 0.00000907531 m3
Dados de identidade - Marca: 1
Elétrico - Circuitos - Dados elétricos: 0 V/1-0 VA
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Mini_Balizador_Romi_2839_2840_Nordecor_IFC: 2840 - Preto; Família e tipo: Mini_Balizador_Romi_2839_2840_Nordecor_IFC: 2840 - Preto; ID de tipo: Mini_Balizador_Romi_2839_2840_Nordecor_IFC: 2840 - Preto; Tipo: Mini_Balizador_Romi_2839_2840_Nordecor_IFC: 2840 - Preto
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
